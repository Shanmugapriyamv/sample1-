# Keil uVision project code.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82F6B08/001/104 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM (0-0x0EFF) CLOCK(36000000)
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 code.c API_Macro_MG82F6B08_001_104.h API_Uart_BRGRL_MG82F6B08_001_104.h REG_MG82F6B08_001_104.h TYPE.h
